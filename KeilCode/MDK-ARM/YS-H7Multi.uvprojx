# Keil uVision project YS-H7Multi.uvprojx, settings and files
target YS-H7Multi (5060422::V5.06 update 4 (build 422)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: YS-H7Multi +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Bsp\Inc;..\Bsp\bsp_USARTx_demo;..\Bsp\bsp_USART2_485;..\Bsp\System_Init;..\Bsp\bsp_UART7_485;..\Bsp\bsp_USART1_485;..\Bsp\bsp_UART4_485;..\Bsp\bsp_DO;..\Bsp\bsp_CANFDx_demo;..\Bsp\bsp_CAN1;..\Bsp\bsp_CAN2;..\Bsp\I2C;..\Bsp\EEPROM;..\APP\ParamManager;..\Bsp\bsp_IICx_demo;..\APP\DeviceData;..\APP\DeviceProcess;..\APP\DeviceProcess\BRT38Encoder
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_assert.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_smbus_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group Drivers/CMSIS
    ..//Src/: system_stm32h7xx.c
  group SYSTEM
    ../Bsp/System_Init/: sys.c
  group DeviceData
    ../APP/DeviceData/: BRT38Encoder_Info.c BRT38Encoder_Info.h MS303Gnss_Info.h
  group DeviceProcess
    ../APP/DeviceProcess/BRT38Encoder/: BRT38Encoder_Process.c BRT38Encoder_Process.h
  group bsp_USARTx_demo
    ../Bsp/bsp_USARTx_demo/: bsp_USARTx.c bsp_USARTx_IRQ.c
  group bsp_CANFDx_demo
    ../Bsp/bsp_CANFDx_demo/: bsp_CANFDx.c
  group bsp_USART2_485
    ../Bsp/bsp_USART2_485/: USART2_485.c USART2_485_RxTx.c
  group bsp_CAN1
    ../Bsp/bsp_CAN1/: CAN1.c
  group bsp_CAN2
    ../Bsp/bsp_CAN2/: CAN2.c
  group bsp_UART7_485
    ../Bsp/bsp_UART7_485/: UART7_485.c
  group bsp_USART1_485
    ../Bsp/bsp_USART1_485/: USART1_485.c USART1_485_RxTx.c
  group bsp_UART4_485
    ../Bsp/bsp_UART4_485/: UART4_485.c UART4_485_RxTx.c
  group bsp_DO
    ../Bsp/bsp_DO/: DO.c
  group I2C
    ../Bsp/I2C/: bsp_i2c.c
  group EEPROM
    ../Bsp/EEPROM/: at24c02.c
  group bsp_IICx_demo
    ../Bsp/bsp_IICx_demo/: bsp_IICx_demo.c
  group bsp
    ../Bsp/Src/: bsp_RS485.c bsp_debug_usart.c bsp_CAN.c
  group ParamManager
    ../APP/ParamManager/: param_manager.c
